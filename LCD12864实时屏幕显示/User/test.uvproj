# Keil uVision project test.uvproj, settings and files
target Test (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: test +hex
  group User
    ./: main.c
  group Driver
    ../Driver/: 12864.c Uart.c
